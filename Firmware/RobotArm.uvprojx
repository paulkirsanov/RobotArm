# Keil uVision project RobotArm.uvprojx, settings and files
target RobotArm (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: RobotArm
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\Firmware;.\CMSIS;.\CMSIS\inc;.\CMSIS\src;.\Startup;.\UserSource;.\UserSource\inc;..\Firmware;.\FreeRTOS\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ./CMSIS/src/: core_cm3.c system_stm32f10x.c
  group StartUp
    ./Startup/: startup_stm32f10x_md.s
  group UserSource
    ./UserSource/src/: button.c delay_tim4.c i2c.c lcd.c led.c main.c spi.c stepmotor.c timer.c usart.c
  group FreeRTOS
    ./FreeRTOS/src/: croutine.c event_groups.c heap_1.c list.c port.c queue.c tasks.c timers.c
